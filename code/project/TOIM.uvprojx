# Keil uVision project TOIM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIOM +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\BEEN;.\APP\SysTick;.\APP\KEY;.\APP\LED;.\APP\232;.\APP\TIM;.\APP\RFID;.\APP\spi;.\APP\flash;.\APP\sys;.\APP\delay;.\APP\iwdg;.\APP\hopper
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c public.c variables_def.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
    ./user/: stm32f10x_it.c
  group APP
    ./APP/SysTick/: systick.c
    ./APP/232/: usart.c
    ./APP/TIM/: time.c
    ./APP/spi/: spi.c
    ./APP/flash/: flash.c
    ./APP/RFID/: RC522.c
    ./APP/sys/: sys.c
    ./APP/delay/: delay.c
    ./APP/iwdg/: iwdg.c
    ./APP/hopper/: hopper.c
